IMAGE_BOOT_FILES:append = " overlays/dht11.dtbo"

IMAGE_BOOT_FILES:append = " overlays/led.dtbo"

IMAGE_BOOT_FILES:append = " overlays/dht11mmio.dtbo"